# Keil uVision project Clock.uvprojx, settings and files
target Clock (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Clock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,
  c include: ..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\CMSIS\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\uCOS II\Source;..\uCOS II\Port
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Src/: main.c
  group HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c
  group Usr
    ../Src/: led.c stm32f4xx_it.c
    ../Inc/: led.h
  group CMSIS
    ../Drivers/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group MDK-ARM
    ../Drivers/CMSIS/STM32F4xx/Source/: startup_stm32f407xx.s
  group uCOS II/Src
    ../uCOS II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS II/ Port
    ../uCOS II/Port/: os_cpu_a.asm os_cpu_c.c includes.h os_cfg.h os_cpu.h
